# Ajout du packagegroup personnalisé à l'image
IMAGE_INSTALL:append = " packagegroup-esme"
